## build/Kconfig/Kconfig.soc.arch
```kconfig
osource "/home/lorenz/zephyrproject/zephyr/soc/$(ARCH)/Kconfig"
osource "/home/lorenz/zephyrproject/zephyr/soc/$(ARCH)/*/Kconfig"
```
